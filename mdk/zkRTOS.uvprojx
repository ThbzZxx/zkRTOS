# Keil uVision project zkRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zkRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,STM32F103xB8
  c misc: --locale=english,--charset=utf8
  c include: ..\bsp\stm32f1\core\inc;..\bsp\stm32f1\driver\serial;..\bsp\stm32f1\driver\STM32F10xFWLib\inc;..\config;..\include\private;..\include\public;..\include;..\arch\cm3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f1xx.s
  group Application/User/Core
    ../bsp/stm32f1/core/src/: main.c
  group Drivers/STM32F1xx
    ../bsp/stm32f1/driver/STM32F10xFWLib/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
    ../bsp/stm32f1/driver/serial/: serial.c
  group zkRTOS
    ../src/: zk_board.c zk_hook.c zk_mem.c zk_mutex.c zk_print.c zk_queue.c zk_scheduler.c zk_sem.c zk_task.c zk_time.c zk_timer.c
  group cpuport
    ../arch/cm3/: context_rvds.s zk_cpu_cm3.c
